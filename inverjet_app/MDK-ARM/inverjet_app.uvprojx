# Keil uVision project inverjet_app.uvprojx, settings and files
target inverjet_app (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: inverjet_app +hex
  AfterMake: ..\Tools\after_build_script.exe
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../STM32MB/modbus/include;../STM32MB/port;../STM32MB/modbus/ascii;../STM32MB/modbus/rtu;../STM32MB/modbus/tcp;../Core/app;../Core/Thread;../Core/fyld_mcu_sdk
  asm include: ../Core/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: stmflash.c sys.c main.c gpio.c freertos.c adc.c dma.c i2c.c iwdg.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Modbus
    ../STM32MB/modbus/rtu/: mbcrc.c mbrtu.c
    ../STM32MB/modbus/ascii/: mbascii.c
    ../STM32MB/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c mbfuncfile.c
    ../STM32MB/modbus/tcp/: mbtcp.c
    ../STM32MB/modbus/: mb.c
  group Modbus_prot
    ../STM32MB/port/: portserial.c portevent.c porttimer.c
  group App
    ../Core/app/: dev.c iap.c debug_protocol.c display.c state_machine.c data.c operation.c fault.c tm1621.c bluetooth.c control_interface.c ntc_3950.c my_modbus.c model_parameter.c
  group Thread
    ../Core/Thread/: Breath_light.c key.c timing.c modbus.c motor.c wifi_thread.c macro_definition.h model_parameter.h
  group fyld_mcu_sdk
    ../Core/fyld_mcu_sdk/: mcu_api.c mcu_api.h protocol.c protocol.h readme.txt system.c system.h wifi.h
software components: CMSIS:CORE 5.6.0
